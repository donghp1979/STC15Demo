# Keil uVision project DS18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DS18B20 +hex
  c flags: Optimize=9
  link misc: REMOVEUNUSED
  group APP
    ./: main.c DS18B20.c SysInit.c
  group STC15
    ./STC15/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c USART.C timer.c
